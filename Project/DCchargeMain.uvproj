# Keil uVision project DCchargeMain.uvproj, settings and files
target DCMain (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: DCchargeMain +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Drivers\STM32F2xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\User\Inc;..\Drivers\BSP\STM322xG_EVAL;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\Middlewares\Third_Party\LwIP\src\include;..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\Middlewares\Third_Party\LwIP\system;..\Ucosii\Include;..\Ucosii\Port;..\Ucosii\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_uart.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_usart.c stm32f2xx_ll_usb.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c
  group Middlewares/LwIP/Api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Micrium\Software\uC-CPU
    ../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group User
    ../User/Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c CAN.c DEFINE.c AM2321.c IC_driver.c language.c ds18b20.c TIMER.C PM.c cmd_queue.c hmi.c hmi_driver.c usart.c AT45DB161.c tcp_echoclient.c app_ethernet.c ethernetif.c ETH.c
  group DOC
    ../: ReadMe.txt
